# Repository kami-sona/Kicad_project

## KiCad design boost-convertor/boost-convertor.kicad_pcb

Parts:
C1: 100u; CP_Radial_D8.0mm_P3.50mm
C2: 382pF; C_0603_1608Metric
C3: 113u; CP_Radial_D8.0mm_P3.50mm
C4, C5: 18pf; C_0603_1608Metric
C6, C7, C8: 0.1u; C_0603_1608Metric
D1: IN5819; D_SMA
D2: LED; C_0805_2012Metric
J2: Screw_Terminal_01x02; DB301V-3.5-2P
J3: AVR-ISP-6; AVR-5pin
J4: TYPE-C 6P; CONN_TYPE-C-6P_SHN
L1: 100uH; L_SXN_SMMS0650
LED1: FJ3461AH
Q1: IRL540NSPBF; TO254P1524X483-3N
R1: 27k; R_0603_1608Metric
R2: 180; R_0603_1608Metric
R3: 2.7k; R_0603_1608Metric
R4: 146.7k; R_0603_1608Metric
R5: 16.7k; R_0603_1608Metric
R6: 4.7K; R_0603_1608Metric
R7, R10: 4.7k; R_0603_1608Metric
R8: 3k; R_0603_1608Metric
R9: 9.53k; R_0603_1608Metric
R11, R12: 5.1k; R_0603_1608Metric
R13: 200; R_0603_1608Metric
R14: 10k; R_0603_1608Metric
R15: 100; R_0603_1608Metric
RCS1, RCS2: 0.1 1w; R_1206_3216Metric
RV1: 100k; TRIM_3296W-1-104
U1: ATMEGA328P-AU; TQFP32_32A_MCH
U2: MC34063ECN; DIP254P762X480-8
U3: ADS1115IDGSR; DGS0010A_N
U4: MAX7219; SOP-24_7.5x15.4mm_P1.27mm
Y1: Crystal; Crystal_SMD_HC-49S-SMD-2P-Mini

Connections:
+5V: C1.1, C6.1, C7.1, C8.1, J4.A9 (VBUS), J4.B9 (VBUS), R6.1, R7.1, R9.1, R10.1, R13.1, RCS1.1, RCS2.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.6 (VCC), U3.8 (VDD), U4.19 (V+)
/BOOST_OUTPUT: C3.1, D1.1 (K), J2.1, R1.1, R4.1, RV1.2
/L_IN: L1.1, R2.1, RCS1.2, RCS2.2, U2.7 (IPK)
/L_OUT: D1.2 (A), L1.2, Q1.1 (D), U2.1 (SWC)
/MISO: J3.1 (MISO), U1.16 (PB4(PCINT4/MISO))
/MOSI: J3.2 (MOSI), U1.15 (PB3(PCINT3/OC2A/MOSI)), U4.1 (DIN)
/RESET: J3.4 (~RST), U1.29 (PC6(*RESET/PCINT14))
/SCK: J3.3 (SCK), U1.17 (PB5(SCK/PCINT5)), U4.13 (CLK)
/SS: U1.14 (PB2(PCINT2/*SS/OC1B)), U4.12 (LOAD)
/XTAL1: C4.1, U1.7 (PB6(PCINT6/XTAL1/TOSC1)), Y1.1
/XTAL2: C5.1, U1.8 (PB7(PCINT7/XTAL2/TOSC2)), Y1.2
/sample: R1.2, R8.1, U3.4 (AIN0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D2.1 (K), J2.2, J3.5 (GND), J4.A12 (GND), J4.B12 (GND), Q1.3 (S), R3.1, R8.2, R11.1, R12.1, R14.2, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.4 (GND), U3.1 (ADDR), U3.3 (GND), U4.4 (GND), U4.9 (GND)
unnamed: D2.2 (A), R13.2
unnamed: J4.A5 (CC1), R11.2
unnamed: J4.B5 (CC2), R12.2
unnamed: LED1.9 (G1), U4.2 (DIG_0)
unnamed: LED1.10 (G2), U4.11 (DIG_1)
unnamed: LED1.11 (G3), U4.6 (DIG_2)
unnamed: LED1.12 (G4), U4.7 (DIG_3)
unnamed: LED1.1 (a), U4.14 (SEG_A)
unnamed: LED1.2 (b), U4.16 (SEG_B)
unnamed: LED1.3 (c), U4.20 (SEG_C)
unnamed: LED1.4 (d), U4.23 (SEG_D)
unnamed: LED1.8 (dp), U4.22 (SEG_DP)
unnamed: LED1.5 (e), U4.21 (SEG_E)
unnamed: LED1.6 (f), U4.15 (SEG_F)
unnamed: LED1.7 (g), U4.17 (SEG_G)
unnamed: Q1.2 (G), R14.1, R15.2
unnamed: R5.1, RV1.1
unnamed: R7.2, U1.27 (PC4(ADC4/SDA/PCINT12)), U3.9 (SDA)
unnamed: R6.2, U1.28 (PC5(ADC5/SCL/PCINT13)), U3.10 (SCL)
unnamed: R10.2, U1.32 (PD2(INT0/PCINT18)), U3.2 (ALERT_RDY)
unnamed: R3.2, R4.2, R5.2, U2.5 (CII)
unnamed: R2.2, U2.8 (DRC)
unnamed: R15.1, U2.2 (SWE)
unnamed: C2.1, U2.3 (TC)
unnamed: R9.2, U4.18 (ISET)

Notes on the sheet:
USB供电部分

Board: 4 copper layers, 57.2 x 68.0 mm, 39 parts (0 on the bottom side), 38 nets.

## KiCad design Converter_DC/Converter_DC.kicad_pcb

Board: 2 copper layers, 52.4 x 32.5 mm, 14 parts (0 on the bottom side), 9 nets.

Parts:
C1: 100u; CP_Radial_D8.0mm_P3.50mm
C2: 382pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 113u; CP_Radial_D8.0mm_P3.50mm
D1: 1N5819; DO41-10
J1, J2: Screw_Terminal_01x02; DB301V-3.5-2P
L1: 68uH; L_Radial_D10.0mm_P5.00mm_Fastron_07M
R1: 0; Resistor_L7.0mm_D2.5mm_d0.45mm
R2: 180; Resistor_L7.0mm_D2.5mm_d0.45mm
R3: 2.7k; Resistor_L7.0mm_D2.5mm_d0.45mm
R4: 150k; Resistor_L7.0mm_D2.5mm_d0.45mm
RCS1: 0.225; Resistor_L7.0mm_D2.5mm_d0.45mm
RV1: 100k; TRIM_3296W-1-104
U2: MC34063ECN; DIP254P762X480-8

Connections:
/POWER_INPUT: C1.1, J1.2, RCS1.1, U2.6 (VCC)
/POWER_OUTPUT: C3.1, D1.C, J2.1, R4.1, RV1.2
unnamed: R3.2, R4.2, RV1.1, U2.5 (CII)
unnamed: R2.2, U2.8 (DRC)
unnamed: L1.1, R2.1, RCS1.2, U2.7 (IPK)
unnamed: D1.A, L1.2, U2.1 (SWC)
unnamed: C2.1, U2.3 (TC)
PGND: C1.2, C3.2, J1.1, J2.2, R1.1, U2.2 (SWE), U2.4 (GND)
SGND: C2.2, R1.2, R3.1

## KiCad design learn/learn.kicad_pcb

Parts:
BT1: 1061; BAT_1061; PARTREV F
C1: 100nf; C_0603_1608Metric
D1, D2: 1N4148WT; D_SOD-523
D3: LED; LED_0603_1608Metric
Q1: PNP; SOT-23
RV1, RV2: 10k; R07310N0-LA3.0B2.5-B103-100
SW1: SW_SPDT; MS-12D17-G2
TP1: VCC; TestPoint_Pad_D3.0mm
TP2: GND; TestPoint_Pad_D3.0mm
U1: SOIC127P599X175-8N

Connections:
unnamed: C1.1, D1.2 (A), D2.1 (K), U1.2 (TRIG), U1.6 (THRES)
unnamed: D1.1 (K), RV2.2
unnamed: D2.2 (A), RV1.2, RV2.1, U1.7 (DISCH)
unnamed: D3.2 (A), U1.3 (OUT)
unnamed: D3.1 (K), Q1.2 (B)
unnamed: BT1.P, Q1.1 (C), RV1.1, U1.4 (RESET), U1.8 (VCC)
unnamed: Q1.3 (E), TP1.1
unnamed: BT1.N, SW1.2 (B)
unnamed: C1.2, SW1.3 (C), TP2.1, U1.1 (GND)

Board: 2 copper layers, 61.0 x 48.0 mm, 12 parts (0 on the bottom side), 9 nets.

## Commit log

2025-04-09 Intial commit
2025-04-10 PCB Board Design
2025-04-10 fix pcb bugs
2025-04-10 gerber files ready
2025-04-12 logo added
2025-04-12 materials generated
2025-04-12 gerber files uppdated
2025-04-15 fix capacitor pad size
2025-07-11 add DC_Converter
2025-09-06 add footprint
2025-09-06 add new boost-convertor rpoject
2025-09-10 max7219M/TR symbol
2025-09-10 add new footprint
2025-09-10 fix bugs
2025-09-11 modify footprint
2025-09-11 complete layout
2025-09-13 update foorprint
2025-09-13 The finnal pcb complete
2025-09-13 drill manfacuture files
2025-09-13 gerber manfacuture files
2025-09-24 mosfet footprint added
2025-09-24 add a external mosfet improve ouput power
2025-09-24 correct drc
2025-09-26 v1.1 manufacture files
2025-09-26 add skillscreen
